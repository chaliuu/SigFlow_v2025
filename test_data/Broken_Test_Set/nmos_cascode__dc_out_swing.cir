* C:\Users\Aashl\OneDrive\Documents\4F\ECE331\Lab2\nmos_cascode__dc_out_swing.asc
* Generated by LTspice 24.1.9 for Windows.
Vin N003 0 SINE(1.3693 0.1m 100)
M1 N002 N003 0 0 ALD1101 W=1.379e-3 L=1E-6
M2 Vout N001 N002 N002 ALD1101 W=1.379e-3 L=1E-6
Id 0 Vout 0.001
Vb N001 0 2.2
R1 0 Vout 1e6
.model NMOS NMOS
.model PMOS PMOS
.lib C:\Users\Aashl\AppData\Local\LTspice\lib\cmp\standard.mos
* .dc Vin 1.36 1.38 0.0001
.lib ECE331_354.lib
.op
* .tran 50m
.backanno
.end
